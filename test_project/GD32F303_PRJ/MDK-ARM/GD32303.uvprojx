# Keil uVision project GD32303.uvprojx, settings and files
target GD32F303 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F303RE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F303 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=Object\@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD,__FPU_PRESENT,__TARGET_FPU_VFP
  c include: ..\..\GD32F303_PRJ;..\..\..\software_i2c\lib\CMSIS;..\..\..\software_i2c\lib\CMSIS\GD\GD32F30x\Include;..\..\..\software_i2c\lib\GD32F30x_standard_peripheral\Include;..\..\..\software_i2c;..\SOFT_I2C
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../: main.c gd32f30x_it.c systick.c
  group CMSIS
    ../../../software_i2c/lib/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group GD32F30x_Peripherals
    ../../../software_i2c/lib/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Startup
    ../../../software_i2c/lib/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_cl.s startup_gd32f30x_hd.s startup_gd32f30x_xd.s
  group SOFT_I2C
    ../../../software_i2c/: bsp_soft_i2c.c bsp_soft_i2c.h bsp_soft_i2c_private.h
    ../SOFT_I2C/: soft_i2c_dev.c soft_i2c_dev.h
