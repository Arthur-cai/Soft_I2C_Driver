# Keil uVision project STM32F103.uvprojx, settings and files
target STM32F103C8 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103C8 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=Object\@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD, USE_STM32100E_EVAL,USE_STDPERIPH_DRIVER
  c include: ..\..\STM32F1_PRJ;..\..\..\software_i2c\lib\STM32F10x_StdPeriph_Lib_V3.6.0\CMSIS\CM3\CoreSupport;..\..\..\software_i2c\lib\STM32F10x_StdPeriph_Lib_V3.6.0\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\software_i2c\lib\STM32F10x_StdPeriph_Lib_V3.6.0\STM32F10x_StdPeriph_Driver\inc;..\..\..\software_i2c;..\SOFT_I2C
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../: stm32f10x_it.c main.c
  group StdPeriph_Driver
    ../../../software_i2c/lib/STM32F10x_StdPeriph_Lib_V3.6.0/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../../../software_i2c/lib/STM32F10x_StdPeriph_Lib_V3.6.0/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../software_i2c/lib/STM32F10x_StdPeriph_Lib_V3.6.0/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group MDK-ARM
    ../../../software_i2c/lib/STM32F10x_StdPeriph_Lib_V3.6.0/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group SOFT_I2C
    ../../../software_i2c/: bsp_soft_i2c.c bsp_soft_i2c.h bsp_soft_i2c_private.h
    ../SOFT_I2C/: soft_i2c_dev.c soft_i2c_dev.h
